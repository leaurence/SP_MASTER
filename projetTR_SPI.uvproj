# Keil uVision project projetTR_SPI.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: projetTR_SPI
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Config_SPI.c Config_GPIO.c Config_Global.c Config_Global.h
    ../projetTR_ServoH/: Config_GPIO.h main.c
